RDEPENDS_packagegroup-filogic-mt76:remove_onewifi = " \
                    hostapd \
                    usteer \
                    wifi-test-tool \
                    vts \
                    iwinfo \
                    uci \
                    ubus \
"
RDEPENDS_packagegroup-filogic-mt76_remove_broadband = " mt76-test"
